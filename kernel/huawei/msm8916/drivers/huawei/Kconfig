## kernel/huawei/msm8916/drivers/huawei/Kconfig
```kconfig
menu "huawei linux device driver support package"
source "drivers/huawei/log_module/Kconfig"
endmenu
```
